# IAR project test_app_rev0.ewp, settings and files
configuration test_app_rev0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107RC ST STM32F107RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F107xC
  ICCARM.CCIncludePath2: ../../Core/Inc; ../../LWIP/App; ../../LWIP/Target; ../../Middlewares/Third_Party/LwIP/src/include; ../../Middlewares/Third_Party/LwIP/system; ../../Drivers/STM32F1xx_HAL_Driver/Inc; ../../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../../Middlewares/Third_Party/LwIP/src/apps/httpd; ../../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../../Middlewares/Third_Party/LwIP/src/include/lwip; ../../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../../Middlewares/Third_Party/LwIP/src/include/netif; ../../Middlewares/Third_Party/LwIP/src/include/posix; ../../Middlewares/Third_Party/LwIP/src/include/posix/sys; ../../Middlewares/Third_Party/LwIP/system/arch; ../../Drivers/CMSIS/Include; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang; ..\..\Metrology\tasks\inc; ..\..\Metrology\drivers\inc; ..\..\Metrology\include\inc; ..\..\Middlewares\Third_Party\LwIP\src\apps\ping; ..\..\Middlewares\Third_Party\LwIP\src\apps\snmp; ..\..\Middlewares\Third_Party\LwIP\src\apps\udpecho; ..\..\Middlewares\Third_Party\LwIP\src\include\lwip\apps; ..\..\Middlewares\Third_Party\LwIP\src\include\lwip\apps
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Core\Inc
  OBJCOPY.OOCOutputFile: app_59_V3.bin
  ILINK.IlinkOutputFile: test_app_rev0.out
  ILINK.IlinkIcfFile: stm32f103xg_flash_offset.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f107xc.s
  group Application/User/Core
    ../../Core/Src/: app.c base64.c crc16.c flash_if.c freertos.c hard_config.c html_page.c LOGS.c main.c ntp.c smtp.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c stm32f1xx_it.c syslog.c
    ../../Middlewares/Third_Party/LwIP/src/apps/httpd/: httpserver-netconn.c
    ../../Middlewares/Third_Party/LwIP/src/apps/ping/: ping.c
    ../../Middlewares/Third_Party/LwIP/src/apps/snmp/: snmp_ex.c
  group Application/User/LWIP/App
    ../../LWIP/App/: lwip.c
  group Application/User/LWIP/Target
    ../../LWIP/Target/: ethernetif.c
  group Drivers/CMSIS
    ../../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_5.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Middlewares/LwIP
    ../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c slipif.c
    ../../Middlewares/Third_Party/LwIP/src/apps/httpd/: fs.c httpd.c
    ../../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
    ../../Middlewares/Third_Party/LwIP/src/apps/snmp/: snmp_asn1.c snmp_core.c snmp_mib2.c snmp_mib2_system.c snmp_msg.c snmp_netconn.c snmp_pbuf_stream.c snmp_scalar.c snmp_table.c snmp_threadsync.c snmp_traps.c
    ../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
